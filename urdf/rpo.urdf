Commit message: change battery

File: urdf/rpo.urdf (robot description, URDF)
Before this commit: robot rpourdf, 24 links, 23 joints
Links:
- link torso_link: mass 7.58189737 -> 6.768
